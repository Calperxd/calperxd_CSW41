# IAR project Backup of Lab6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TX_ENABLE_IAR_LIBRARY_SUPPORT
  ICCARM.CCIncludePath2: ..\..\ThreadX\ports\cortex_m4\iar\inc; ..\..\ThreadX\common\inc; ..\..\ThreadX\common\src; ..\..\ThreadX; ..\..\TivaWare_C_Series-2.2.0.295; ..\..\TivaWare_C_Series-2.2.0.295\driverlib\ewarm; ..\..\TivaWare_C_Series-2.2.0.295\driverlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lab6.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Program Files\IAR Systems\Embedded Workbench 9.0\arm\config\linker\TexasInstruments\TM4C1294NC.icf
  ILINK.IlinkAdditionalLibs: ..\..\ThreadX\ports\cortex_m4\iar\example_build\Debug\Exe\tx.a; ..\..\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src
    src/: cstartup_M.s main.c tx_initialize_low_level.s
