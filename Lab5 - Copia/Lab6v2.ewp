# IAR project Lab6v2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TX_ENABLE_IAR_LIBRARY_SUPPORT
  ICCARM.CCIncludePath2: ..\..\ThreadX; ..\..\ThreadX\common\inc; ..\..\ThreadX\ports\cortex_m4\iar\inc; ..\..\TivaWare_C_Series-2.2.0.295; ..\..\TivaWare_C_Series-2.2.0.295\driverlib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: tx.a; ..\..\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    src/: cstartup_M.s sample_threadx.c tx_initialize_low_level.s
